# Keil uVision project EBF_RA4M2.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: R7FA4M2AD Renesas
  pack: Renesas.RA_DFP.6.3.1
  cpu: IRAM(0x20000000,0x020000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: EBF_RA4M2
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "4.1.0" -nosplash --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src\debug_uart;.\src\bsp_esp8266;.\src\circle_buf;.\ra_gen;.\ra\fsp\src;.\ra\fsp\inc\api;.\ra\fsp\inc;.\ra_cfg\fsp_cfg\bsp;.\ra\arm\CMSIS_6\CMSIS\Core\Include;.\ra\fsp\inc\instances;.\ra_cfg\fsp_cfg;.\src\cJSON;.\src\cJSON_handle;.\src\Systick;.\src\led;.\src\uart_hlw;.\src\Key;.\src\Relay;.\src\sdhi_sdcard;.\src\sdcard_data_handle;.\src\sdhi_sdcard;.\src\FatFs\ff15;..\Appliance identification;.\src\Appliance identification algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
    ./src/bsp_esp8266/: bsp_wifi_esp8266.c bsp_wifi_esp8266.h
    ./src/debug_uart/: bsp_debug_uart.c bsp_debug_uart.h
    ./src/circle_buf/: circle_buf.c circle_buf.h
    ./src/cJSON/: cJSON.c cJSON.h
    ./src/cJSON_handle/: cJSON_handle.c cJSON_handle.h
    ./src/Systick/: Systick.c Systick.h
    ./src/led/: bsp_led.c bsp_led.h
    ./src/uart_hlw/: uart_hlw.c uart_hlw.h
    ./src/Key/: Key.c Key.h
    ./src/Relay/: Relay.c Relay.h
    ./src/sdhi_sdcard/: bsp_sdhi_sdcard.c bsp_sdhi_sdcard.h
    ./src/sdcard_data_handle/: sdcard_data_handle.c sdcard_data_handle.h
    ./src/Appliance identification algorithm/: appliance_identification.c appliance_identification.h
  group FatFs
    ./src/FatFs/ff15/: diskio.c diskio.h ff.c ff.h ffconf.h ffunicode.c
software components: Flex Software:RA Configuration 1.0.0
